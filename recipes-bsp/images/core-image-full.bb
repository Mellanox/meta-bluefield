SUMMARY = "An image with most of the non-graphical libraries and \
development tools.  This image is generally useful for bluefield \
based storage devices."

require recipes-extended/images/core-image-lsb.bb

include core-image-full.inc
