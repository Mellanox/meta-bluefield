# Prevent No GNU_HASH in the elf binary error

INSANE_SKIP_${PN} = "ldflags"
