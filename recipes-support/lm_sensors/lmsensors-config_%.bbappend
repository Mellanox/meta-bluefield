FILESEXTRAPATHS_prepend := "${THISDIR}/lmsensors-config:"
