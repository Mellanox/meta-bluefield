FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append = " file://decode-dimms-Add-support-for-DDR4-SDRAM-memory.patch"
